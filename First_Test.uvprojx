# Keil uVision project First_Test.uvprojx, settings and files
target MAIN (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L011F4Px STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00000800) IROM(0x08000000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: First_Test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;.\SPI;.\LCD;.\Keypad
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source
    ./: main.c
  group Drivers
    C:/Users/Robert/Desktop/STM32NUCLEO/STM32L011chipTest/Src/: system_stm32l0xx.c
    C:/Users/Robert/Desktop/STM32NUCLEO/STM32L011chipTest/MDK-ARM/: startup_stm32l011xx.s
  group SPI
    ./SPI/: SPI_STM32l011.c SPI_STM32l011.h
  group LCD
    ./LCD/: LCD_SPI.c LCD_SPI.h
  group Font
    ./LCD/: font.h
  group Keypad
    ./Keypad/: Keypad.c Keypad.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.7.2
